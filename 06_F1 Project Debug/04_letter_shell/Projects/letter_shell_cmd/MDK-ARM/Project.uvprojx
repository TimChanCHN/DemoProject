# Keil uVision project Project.uvprojx, settings and files
target FT32F030X (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32F103VE HK_MicroChip
  pack: HKMicroChip.HK32F1xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FT32F0XX +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_DEFAULT_TIMEOUT_CALLBACK,DEBUG,F1, HK32F103
  c include: ..\;..\app;..\..\..\develop_lib;..\..\..\develop_lib\third_lib;..\..\..\develop_lib\third_lib\crc32;..\..\..\develop_lib\third_lib\queue;..\..\..\develop_lib\third_lib\app_timer;..\..\..\develop_lib\third_lib\ntshell\util;..\..\..\develop_lib\third_lib\ntshell\core;..\..\..\develop_lib\third_lib\letter-shell\src;..\..\..\develop_lib\third_lib\app_scheduler;..\..\..\develop_lib\hardware;..\..\..\develop_lib\hardware\st7789;..\..\..\develop_lib\hardware\nt35510;..\..\..\develop_lib\hk_lib;..\..\..\develop_lib\hk_lib\HK32F103\CMSIS\CM3\CoreSupport;..\..\..\develop_lib\hk_lib\HK32F103\STM32F10x_StdPeriph_Driver\inc;..\..\..\develop_lib\hk_lib\HK32F103\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\develop_lib\middle_api_new;..\..\..\develop_lib\middle_api_new\ir;..\..\..\develop_lib\middle_api_new\adc;..\..\..\develop_lib\middle_api_new\delay;..\..\..\develop_lib\middle_api_new\mid_gpio;..\..\..\develop_lib\middle_api_new\mid_tftlcd;..\..\..\develop_lib\middle_api_new\mid_flash;..\..\..\develop_lib\middle_api_new\mid_usart;..\..\..\develop_lib\middle_api_new\mid_bk953x;..\..\..\develop_lib\middle_api_new\mid_systick;..\..\..\develop_lib\middle_api_new\trace;..\..\..\develop_lib\Fx_api\F1_api;..\..\..\develop_lib\Fx_api\F1_api\gpio;..\..\..\develop_lib\Fx_api\F1_api\systick;..\..\..\develop_lib\Fx_api\F1_api\usart;..\..\..\develop_lib\Fx_api\F1_api\FSMC;..\..\..\develop_lib\user_command;..\..\..\develop_lib\user_command\cmd_list;..\..\..\develop_lib\user_command\nt_shell_cmd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../../../develop_lib/hk_lib/HK32F103/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../develop_lib/hk_lib/HK32F103/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/: startup_stm32f10x_hd.s
    ../../../develop_lib/hk_lib/HK32F103/CMSIS/CM3/CoreSupport/: core_cm3.c
  group app
    ../: main.c
    ../../../develop_lib/hk_lib/HK32F103/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x_it.c
    ../app/: fsmc_8b.c letter_shell_handler.c
  group StdPeriph_Driver
    ../../../develop_lib/hk_lib/HK32F103/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hardware
    ../../../develop_lib/hardware/st7789/: st7789.c
  group middle_api
    ../../../develop_lib/middle_api_new/mid_gpio/: mid_gpio.c
    ../../../develop_lib/middle_api_new/mid_systick/: mid_systick.c
    ../../../develop_lib/middle_api_new/delay/: mid_delay.c
    ../../../develop_lib/middle_api_new/mid_usart/: mid_usart.c
    ../../../develop_lib/middle_api_new/mid_tftlcd/: mid_tftlcd.c
  group third_lib
    ../../../develop_lib/third_lib/ntshell/core/: ntlibc.c ntshell.c text_editor.c text_history.c vtrecv.c vtsend.c
    ../../../develop_lib/third_lib/ntshell/util/: ntopt.c ntstdio.c
  group f1_lib
    ../../../develop_lib/Fx_api/F1_api/gpio/: f1_gpio.c
    ../../../develop_lib/Fx_api/F1_api/systick/: f1_systick.c
    ../../../develop_lib/Fx_api/F1_api/usart/: f1_usart.c retarget.c
    ../../../develop_lib/Fx_api/F1_api/FSMC/: f1_fsmc.c
  group cmd_function
    ../../../develop_lib/user_command/nt_shell_cmd/: ntshell_usrcmd.c
    ../../../develop_lib/user_command/cmd_list/: cmd_list.c
  group letter_shell
    ../../../develop_lib/third_lib/letter-shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
