# Keil uVision project Project.uvprojx, settings and files
target FT32F030X (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FT32F030G8BUx FMD
  pack: FMD.FT32F0xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FT32F0XX +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FT32F030x8,USE_STDPERIPH_DRIVER,USE_FT32F030XX_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK,FT32,DEBUG,F0
  c include: ..\;..\..\..\develop_lib\ft_lib\FT_Libraries\CMSIS\Include;..\..\..\develop_lib\ft_lib\FT_Libraries\FT32F0xx_StdPeriph_Driver\inc;..\..\..\develop_lib\ft_lib\FT_Libraries\CMSIS\Device\FT\FT32F0xx\Include;..\..\..\Utilities\FT32_EVAL\Common;..\..\..\Utilities\FT32_EVAL\FT32F030xx_EVAL;..\..\..\develop_lib\third_lib;..\..\..\develop_lib\third_lib\app_timer;..\..\..\develop_lib\third_lib\crc32;..\..\..\develop_lib\third_lib\app_scheduler;..\..\..\develop_lib;..\..\..\develop_lib\hardware;..\..\..\develop_lib\hardware\bk953x;..\..\..\develop_lib\hardware\ht1621;..\..\..\develop_lib\hardware\st7789;..\app;..\..\..\develop_lib\Fx_api\F0_api;..\..\..\develop_lib\Fx_api\F0_api\i2c;..\..\..\develop_lib\Fx_api\F0_api\spi;..\..\..\develop_lib\Fx_api\F0_api\adc;..\..\..\develop_lib\Fx_api\F0_api\exit;..\..\..\develop_lib\Fx_api\F0_api\flash;..\..\..\develop_lib\Fx_api\F0_api\gpio;..\..\..\develop_lib\Fx_api\F0_api\timer;..\..\..\develop_lib\Fx_api\F0_api\usart;..\..\..\develop_lib\Fx_api\F0_api\systick;..\..\..\develop_lib\Fx_api\F0_api\deprecated;..\..\..\develop_lib\Fx_api\F0_api\timer_pwm;..\..\..\develop_lib\middle_api_new;..\..\..\develop_lib\middle_api_new\ir;..\..\..\develop_lib\middle_api_new\adc;..\..\..\develop_lib\middle_api_new\pwm;..\..\..\develop_lib\middle_api_new\trace;..\..\..\develop_lib\middle_api_new\delay;..\..\..\develop_lib\middle_api_new\tft_8080;..\..\..\develop_lib\middle_api_new\mid_gpio;..\..\..\develop_lib\middle_api_new\mid_flash;..\..\..\develop_lib\middle_api_new\mid_tftlcd;..\..\..\develop_lib\middle_api_new\mid_timer;..\..\..\develop_lib\middle_api_new\mid_usart;..\..\..\develop_lib\middle_api_new\mid_bk953x;..\..\..\develop_lib\middle_api_new\mid_kt0646;..\..\..\develop_lib\middle_api_new\mid_kt0656;..\..\..\develop_lib\middle_api_new\mid_systick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../develop_lib/ft_lib/FT_Libraries/CMSIS/Device/FT/FT32F0xx/Source/Templates/: system_ft32f0xx.c
    ../../../develop_lib/ft_lib/FT_Libraries/CMSIS/Device/FT/FT32F0xx/Source/Templates/arm/: startup_ft32f030x8.s
  group app
    ../: main.c
    ../app/: tft_lcd_handler.c
    ../../../develop_lib/ft_lib/FT_Libraries/CMSIS/Device/FT/FT32F0xx/Source/Templates/: ft32f0XX_it.c
  group StdPeriph_Driver
    ../../../develop_lib/ft_lib/FT_Libraries/FT32F0xx_StdPeriph_Driver/src/: FT32f0xx_adc.c FT32f0xx_crc.c FT32f0xx_crs.c FT32f0xx_dbgmcu.c FT32f0xx_exti.c FT32f0xx_flash.c FT32f0xx_gpio.c FT32f0xx_i2c.c FT32f0xx_iwdg.c FT32f0xx_misc.c FT32f0xx_pwr.c FT32f0xx_rcc.c FT32f0xx_spi.c FT32f0xx_syscfg.c FT32f0xx_tim.c FT32f0xx_usart.c
  group hardware
    ../../../develop_lib/hardware/st7789/: st7789.c
  group middle_api
    ../../../develop_lib/middle_api_new/delay/: mid_delay.c
    ../../../develop_lib/middle_api_new/mid_gpio/: mid_gpio.c
    ../../../develop_lib/middle_api_new/mid_systick/: mid_systick.c
    ../../../develop_lib/middle_api_new/adc/: mid_adc.c
    ../../../develop_lib/middle_api_new/mid_tftlcd/: mid_tftlcd.c
  group f0_lib
    ../../../develop_lib/Fx_api/F0_api/gpio/: f0_gpio.c
    ../../../develop_lib/Fx_api/F0_api/systick/: f0_systick.c
    ../../../develop_lib/Fx_api/F0_api/timer/: f0_timer.c
    ../../../develop_lib/Fx_api/F0_api/usart/: f0_usart.c retarget.c
    ../../../develop_lib/Fx_api/F0_api/exit/: f0_exit.c
    ../../../develop_lib/Fx_api/F0_api/adc/: f0_adc.c
